# Keil uVision project FoLogic.uvproj, settings and files
target FoLogic (MCS-51)
  device: EZ-USB FX2 (CY7C68XXX) Cypress
  cpu: IRAM(0-0xFF) IROM(0-0x1FFF) XRAM(0xE000-0xE1FF) CLOCK(48000000) MODDP2
  output: FoLogic +hex
  AfterMake: .\hex2bix -b -o .\Output\FoLogic.fw .\Output\FoLogic.hex
  AfterMake: .\hex2bix -i -f 0xc2 -v 0xb404 -p 0x1386 -o .\Output\FoLogic.iic .\Output\FoLogic.hex
  c flags: Optimize=8 SizeSpeed=1
  group Source Group 1
    ./Source/: fw.c dscr.a51 EZUSB.LIB USBJmpTb.OBJ interface.c FoLogic.c
